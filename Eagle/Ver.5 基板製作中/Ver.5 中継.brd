# Repository All-outlook/All_outlook-Hardwere

File README.md:

# All_outlook-Hardwere
All_outlookのハードウェア用リポジトリでーす！！

## EAGLE design Eagle/Ver.5 基板製作中/Ver.5 中継.brd

Parts:
1, 2, 4, 8: LED1608
LED1, LED2, LED3, LED4: LED1608
Q1, Q2, Q3, Q4, Q5: BSS138; SOT23
S2: SKRPACE010; SW_SKRPACE010
SV1: ML14
SV2: ML10
SV4: ML6
U2: STM32F303K8T6; QFP80P900X900X160-32N
U$1, U$2, U$3, U$4, U$5: 1MMCON
U$6, U$7, U$8, U$9, U$10, U$11, U$19, U$20, U$21, U$22, U$23, U$24, U$25, U$26, U$28, U$29, U$30, U$31, U$33, U$34, U$35, U$36, U$37, U$38, U$39: R; 1608
U$12, U$13, U$15, U$17, U$18, U$40: 1608; CON
U$14, U$27: UI
U$16: SUISYOU; 水晶
U$32: SSW
X1: B6B-PH-K-S
X2: B8B-PH-K-S

Connections:
3V: SV1.1, SV1.2, SV2.1, SV2.2, SV4.1, U$14.P$1 (+5V), X1.1, X2.1
5V: SV1.12, SV2.4, U$14.P$8 (S5)
5V_LED_B: Q4.3 (D), U$4.P$8, U$20.P$1
5V_LED_C: Q5.3 (D), U$5.P$8, U$22.P$1
5V_LED_L: Q1.3 (D), U$2.P$8, U$7.P$1
5V_LED_R: Q2.3 (D), U$1.P$8, U$35.P$1
+3V3: Q1.1 (G), Q2.1 (G), Q3.1 (G), Q4.1 (G), Q5.1 (G), U2.1 (VDD_1), U2.5 (VDDA/VREF+), U2.17 (VDD_2), U$1.P$1, U$2.P$1, U$3.P$1, U$4.P$1, U$5.P$1, U$6.P$2, U$8.P$2, U$10.P$2, U$12.P$1 (1), U$13.P$1 (1), U$19.P$2, U$21.P$2, U$27.P$1 (+5V), U$34.P$2, U$40.P$1 (1)
+5V: U$1.P$7, U$2.P$7, U$3.P$7, U$4.P$7, U$5.P$7, U$7.P$2, U$9.P$2, U$20.P$2, U$22.P$2, U$27.P$8 (S5), U$35.P$2
+5_LED_F: Q3.3 (D), U$3.P$8, U$9.P$1
+12V: SV2.3
A: U2.27 (PB4), U$1.P$3, U$2.P$3, U$3.P$3, U$4.P$3, U$5.P$3, U$28.P$1
ALL: U$14.P$9 (SCL), U$32.P$3
ALL_LED: SV1.13, SV2.7, U$32.P$1, X1.2, X2.2
B: U2.28 (PB5), U$1.P$4, U$2.P$4, U$3.P$4, U$4.P$4, U$5.P$4, U$29.P$1
BGND: SV1.14, SV2.8, SV2.9, SV2.10, SV4.3, U$14.P$10 (SDA), X1.6, X2.8
C: U2.29 (PB6), U$1.P$5, U$2.P$5, U$3.P$5, U$4.P$5, U$5.P$5, U$30.P$1
COM_B: U2.14 (PB0), U$4.P$2, U$38.P$2
COM_C: U2.15 (PB1), U$5.P$2, U$39.P$2
COM_F: U2.13 (PA7), U$3.P$2, U$37.P$2
COM_L: U2.12 (PA6), U$2.P$2, U$33.P$2
COM_R: U2.11 (PA5), U$1.P$2, U$36.P$2
D: U2.30 (PB7), U$1.P$6, U$2.P$6, U$3.P$6, U$4.P$6, U$5.P$6, U$31.P$1
GND: S2.3, S2.4, U2.16 (VSS_2), U2.32 (VSS_1), U$1.P$9, U$2.P$9, U$3.P$9, U$4.P$9, U$5.P$9, U$11.P$1, U$12.P$2 (2), U$13.P$2 (2), U$15.P$2 (2), U$17.P$2 (2), U$18.P$2 (2), U$27.P$10 (SDA), U$33.P$1, U$36.P$1, U$37.P$1, U$38.P$1, U$39.P$1, U$40.P$2 (2)
LED: 1.K, 2.K, 4.K, 8.K, LED1.K, LED2.K, LED3.K, LED4.K, U$27.P$9 (SCL)
LED_1: U2.18 (PA8), U$23.P$1
LED_2: U2.21 (PA11), U$24.P$1
LED_3: U2.22 (PA12), U$25.P$1
LED_4: U2.25 (PA15), U$26.P$1
LED_B: Q4.2 (S), U2.9 (PA3), U$19.P$1
LED_C: Q5.2 (S), U2.10 (PA4), U$21.P$1
LED_F: Q3.2 (S), U2.8 (PA2), U$8.P$1
LED_L: Q1.2 (S), U2.7 (PA1), U$6.P$1
LED_R: Q2.2 (S), U2.6 (PA0), U$34.P$1
unnamed: U2.31 (BOOT0), U$11.P$2
unnamed: U2.2 (PF0/OSC_IN), U$16.P$1, U$17.P$1 (1)
unnamed: U2.3 (PF1/OSC_OUT), U$16.P$2, U$18.P$1 (1)
unnamed: 8.A, U$31.P$2
unnamed: 4.A, U$30.P$2
unnamed: 2.A, U$29.P$2
unnamed: 1.A, U$28.P$2
unnamed: LED2.A, U$24.P$2
unnamed: LED1.A, U$23.P$2
unnamed: LED3.A, U$25.P$2
unnamed: LED4.A, U$26.P$2
RST: S2.1, S2.2, U2.4 (NRST), U$10.P$1, U$15.P$1 (1), U$27.P$5 (S2)
RST_1: SV1.9, X1.5
RST_2: SV1.10, X2.5
RST_3: SV1.11, SV4.5, U$14.P$5 (S2)
RX: U2.20 (PA10), U$27.P$7 (S4)
RX_1: SV1.4, X1.4
RX_2: SV1.6, X2.4
RX_3: SV1.8, U$14.P$7 (S4)
SCL: SV2.5, X2.6
SDA: SV2.6, X2.7
SWO: SV4.6, U$14.P$4 (S1)
SWO_A: U2.26 (PB3), U$27.P$4 (S1)
TCK: SV4.2, U$14.P$3 (S0)
TCK_A: U2.24 (PA14), U$27.P$3 (S0)
TMS: SV4.4, U$14.P$2 (GND)
TMS_A: U2.23 (PA13), U$27.P$2 (GND)
TX: U2.19 (PA9), U$27.P$6 (S3)
TX_1: SV1.3, X1.3
TX_2: SV1.5, X2.3
TX_3: SV1.7, U$14.P$6 (S3)

Notes on the sheet:
中継to電源
中継toメイン
ライン書き込み
toMD
toキッカー

Board: 2 copper layers, 79.6 x 52.2 mm, 60 parts (23 on the bottom side), 63 nets.

## EAGLE design Eagle/Ver.5 基板製作中/ライン_左.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C17, C18: 1608; CON
IC1: 74HC4067PW,118; SOP65P640X110-24N
R1, R2, R3, R4, R5, R6, R7, R17, R18: R; 1608
U$4, U$5, U$6, U$7, U$8, U$9, U$10: LED
U$11: 1MMCON
U$12, U$13: 1608; CON
U$14, U$16, U$18, U$20, U$22, U$24, U$26, U$28, U$30: 2CS2712; TRANS_SSM3J325F,LF
U$15, U$17, U$19, U$21, U$23, U$25, U$27, U$29, U$31: フォトダイオード

Connections:
1: IC1.10 (S0), U$11.P$3
2: IC1.11 (S1), U$11.P$4
3: IC1.14 (S2), U$11.P$5
4: IC1.13 (S3), U$11.P$6
+3V3: IC1.24 (VCC), U$11.P$1, U$12.P$1 (1), U$14.C, U$15.C, U$16.C, U$17.C, U$18.C, U$19.C, U$20.C, U$21.C, U$22.C, U$23.C, U$24.C, U$25.C, U$26.C, U$27.C, U$28.C, U$29.C, U$30.C, U$31.C
+5V: U$4.P$1 (VDD), U$5.P$1 (VDD), U$6.P$1 (VDD), U$7.P$1 (VDD), U$8.P$1 (VDD), U$9.P$1 (VDD), U$10.P$1 (VDD), U$11.P$7, U$13.P$1 (1)
A_COM: IC1.1 (Z), U$11.P$2
GND: C1.P$2 (2), C2.P$2 (2), C3.P$2 (2), C4.P$2 (2), C5.P$2 (2), C6.P$2 (2), C7.P$2 (2), C17.P$2 (2), C18.P$2 (2), IC1.12 (GND), IC1.15 (!E), R1.P$1, R2.P$1, R3.P$1, R4.P$1, R5.P$1, R6.P$1, R7.P$1, R17.P$1, R18.P$1, U$4.P$3 (GND), U$5.P$3 (GND), U$6.P$3 (GND), U$7.P$3 (GND), U$8.P$3 (GND), U$9.P$3 (GND), U$10.P$3 (GND), U$11.P$9, U$12.P$2 (2), U$13.P$2 (2)
LED: U$10.P$4 (DIN), U$11.P$8
unnamed: U$4.P$4 (DIN), U$5.P$2 (DOUT)
unnamed: U$7.P$4 (DIN), U$8.P$2 (DOUT)
unnamed: U$8.P$4 (DIN), U$9.P$2 (DOUT)
unnamed: U$9.P$4 (DIN), U$10.P$2 (DOUT)
unnamed: U$5.P$4 (DIN), U$6.P$2 (DOUT)
unnamed: U$6.P$4 (DIN), U$7.P$2 (DOUT)
unnamed: U$14.B, U$15.A
unnamed: U$16.B, U$17.A
unnamed: U$18.B, U$19.A
unnamed: U$20.B, U$21.A
unnamed: U$22.B, U$23.A
unnamed: U$24.B, U$25.A
unnamed: U$26.B, U$27.A
unnamed: U$28.B, U$29.A
unnamed: U$30.B, U$31.A
S1: C1.P$1 (1), IC1.9 (Y0), R1.P$2, U$14.E
S2: C2.P$1 (1), IC1.8 (Y1), R2.P$2, U$16.E
S3: C3.P$1 (1), IC1.7 (Y2), R3.P$2, U$18.E
S4: C4.P$1 (1), IC1.6 (Y3), R4.P$2, U$20.E
S5: C5.P$1 (1), IC1.5 (Y4), R5.P$2, U$22.E
S6: C6.P$1 (1), IC1.4 (Y5), R6.P$2, U$24.E
S7: C7.P$1 (1), IC1.3 (Y6), R7.P$2, U$26.E
S8: C17.P$1 (1), IC1.2 (Y7), R17.P$2, U$28.E
S9: C18.P$1 (1), IC1.23 (Y8), R18.P$2, U$30.E

Board: 2 copper layers, 59.2 x 69.4 mm, 47 parts (18 on the bottom side), 33 nets.

## EAGLE design Eagle/Ver.5 基板製作中/UI.brd

Parts:
AT_BT: LED1608
BLUE: LED1608
CAMERA: LED1608
DRIVER: LED1608
IC1: CD74HC4067M96; SOIC127P1030X265-24N
IR: LED1608
JYRO: LED1608
JYRO_RST: LED1608
KICKER: LED1608
LINE: LED1608
RESET: LED1608
START: LED1608
U$1, U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9, U$10, U$11, U$12, U$13, U$14, U$15, U$16, U$17, U$18, U$19, U$20, U$21, U$22, U$23, U$24, U$25, U$26, U$27, U$30, U$32, U$33, U$40, U$41, U$42, U$43, U$44: R; 1608
U$28: DIPSW4
U$29, U$34, U$37, U$38, U$39: TAKUTO; 12
U$31: S
U$35: SSW
U$36: DIPSW8
U$45: LPRP; LPRO
U$46: LCDEN; LCD
U$48: 1608; CON
U$49: ALL
WIRELESS: LED1608
YELLOW: LED1608
Ⅰ: LED1608
Ⅱ: LED1608
Ⅲ: LED1608
Ⅳ: LED1608

Connections:
0: IC1.10 (S0), U$45.P$17
1: IC1.11 (S1), U$45.P$18
2: IC1.14 (S2), U$45.P$19
3: IC1.13 (S3), U$45.P$20
+3V3: IC1.24 (VCC), U$28.P$1, U$28.P$2, U$28.P$3, U$28.P$4, U$31.P$3 (2), U$34.P$1, U$34.P$2, U$35.P$3, U$36.P$1, U$36.P$2, U$36.P$3, U$36.P$4, U$36.P$5, U$36.P$6, U$36.P$7, U$36.P$8, U$37.P$1, U$37.P$2, U$38.P$1, U$38.P$2, U$39.P$1, U$39.P$2, U$45.P$1, U$46.P$1 (VCC), U$48.P$1 (1)
ALL_LED: AT_BT.K, BLUE.K, CAMERA.K, DRIVER.K, IR.K, JYRO.K, JYRO_RST.K, KICKER.K, LINE.K, RESET.K, START.K, U$45.P$21, WIRELESS.K, YELLOW.K, Ⅰ.K, Ⅱ.K, Ⅲ.K, Ⅳ.K
B: IC1.19 (I12), U$25.P$1, U$26.P$1, U$35.P$2
BL: U$45.P$15, U$46.P$8 (BL)
CLK: U$45.P$11, U$46.P$4 (CLK)
COM: IC1.1 (COMMON_INPUT/OUTPUT), U$45.P$16
CS: U$45.P$12, U$46.P$5 (CS)
DC: U$45.P$13, U$46.P$6 (DC)
DIN: U$45.P$10, U$46.P$3 (DIN)
DIP1: IC1.23 (I8), U$17.P$1, U$18.P$1, U$28.P$8
DIP2: IC1.22 (I9), U$19.P$1, U$20.P$1, U$28.P$7
DIP3: IC1.21 (I10), U$21.P$1, U$22.P$1, U$28.P$6
DIP4: IC1.20 (I11), U$23.P$1, U$24.P$1, U$28.P$5
GND: IC1.12 (GND), IC1.15 (!E), U$2.P$2, U$4.P$2, U$6.P$2, U$8.P$2, U$10.P$2, U$12.P$2, U$14.P$2, U$16.P$2, U$18.P$2, U$20.P$2, U$22.P$2, U$24.P$2, U$26.P$2, U$29.P$3, U$29.P$4, U$30.P$2, U$33.P$2, U$40.P$2, U$41.P$2, U$42.P$2, U$45.P$22, U$46.P$2 (GND), U$48.P$2 (2)
JYRO_LED: U$43.P$1, U$45.P$5
JYRO_RST: U$30.P$1, U$34.P$3, U$34.P$4, U$45.P$3
LCD_RST: U$45.P$14, U$46.P$7 (RST)
L_SW: U$39.P$3, U$39.P$4, U$42.P$1, U$45.P$9
unnamed: JYRO_RST.A, U$43.P$2
unnamed: START.A, U$32.P$2
unnamed: AT_BT.A, U$1.P$2
unnamed: CAMERA.A, U$3.P$2
unnamed: RESET.A, U$44.P$2
unnamed: DRIVER.A, U$5.P$2
unnamed: KICKER.A, U$7.P$2
unnamed: U$9.P$2, WIRELESS.A
unnamed: JYRO.A, U$11.P$2
unnamed: LINE.A, U$13.P$2
unnamed: IR.A, U$15.P$2
unnamed: U$17.P$2, Ⅰ.A
unnamed: U$19.P$2, Ⅱ.A
unnamed: U$21.P$2, Ⅲ.A
unnamed: U$23.P$2, Ⅳ.A
unnamed: BLUE.A, U$25.P$2
unnamed: U$27.P$2, YELLOW.A
RESET: U$29.P$1, U$29.P$2, U$45.P$2
RESET_LED: U$44.P$1, U$45.P$4
R_SW: U$37.P$3, U$37.P$4, U$40.P$1, U$45.P$7
S1: IC1.9 (I0), U$1.P$1, U$2.P$1, U$36.P$16
S2: IC1.8 (I1), U$3.P$1, U$4.P$1, U$36.P$15
S3: IC1.7 (I2), U$5.P$1, U$6.P$1, U$36.P$14
S4: IC1.6 (I3), U$7.P$1, U$8.P$1, U$36.P$13
S5: IC1.5 (I4), U$9.P$1, U$10.P$1, U$36.P$12
S6: IC1.4 (I5), U$11.P$1, U$12.P$1, U$36.P$11
S7: IC1.3 (I6), U$13.P$1, U$14.P$1, U$36.P$10
S8: IC1.2 (I7), U$15.P$1, U$16.P$1, U$36.P$9
ST: U$31.P$2 (1), U$32.P$1, U$33.P$1, U$45.P$6
S_SW: U$38.P$3, U$38.P$4, U$41.P$1, U$45.P$8
Y: U$27.P$1, U$35.P$1

Parts:
U$47: LPRP; LPRO

Board: 2 copper layers, 95.2 x 60.0 mm, 67 parts (20 on the bottom side), 53 nets.

## EAGLE design Eagle/Ver.5 基板製作中/ESP32.brd

Parts:
3V: LED1608
EN1: SKRPACE010; SW_SKRPACE010
IC2: ESP32-WROVER-E_M213EH2864PH3Q0; ESP32WROVEREM213EH2864PH3Q0
IO1: SKRPACE010; SW_SKRPACE010
IO25, IO26, IO27, IO32, IO33: LED1608
J3: ZX62R-B-5P; HRS_ZX62R-B-5P
Q5, Q6: BSS138; SOT23
SJ1: SJ
U1: NJM2845DL1-33-TE1; DPAK228P968X238-4N
U$1, U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9, U$11, U$12, U$13, U$82: R; 1608
U$10, U$89, U$90: SSW
U$14: ALL
U$46, U$61, U$80, U$81, U$83: 1608; CON
U$79: CH340K
U$84: 2SW
X2: B5B-PH-K-S
Ⅰ_A: LED1608
Ⅰ_B: LED1608
Ⅱ_A: LED1608
Ⅱ_B: LED1608

Connections:
+3V3: IC2.2 (3V3), U1.3 (VOUT), U$1.P$1, U$61.P$1 (1), U$79.P$7, U$79.P$10, U$80.P$1 (1), U$82.P$2, U$89.P$3, U$90.P$3, X2.1
+5V: J3.1, U1.1 (VIN), U$46.P$1 (1)
ALL_LED: SJ1.2, U$10.P$1, X2.5
ESP_EN: EN1.1, EN1.2, IC2.3 (EN), Q5.3 (D), U$81.P$1 (1), U$82.P$1, U$83.P$1 (1)
ESP_RX: IC2.34 (RXD0), U$84.P$2
ESP_TX: IC2.35 (TXD0), U$84.P$5
ESP_USB_RX: U$79.P$8, U$84.P$1
ESP_USB_TX: U$79.P$9, U$84.P$6
GND: EN1.3, EN1.4, IC2.1 (GND_1), IC2.15 (GND_2), IC2.38 (GND_3), IC2.39 (GND_4), IC2.40 (GND_5), IC2.41 (GND_6), IC2.42 (GND_7), IC2.43 (GND_8), IC2.44 (GND_9), IC2.45 (GND_10), IC2.46 (GND_11), IC2.47 (GND_12), IO1.3, IO1.4, J3.5, J3.S1 (SHIELD), J3.S2 (SHIELD), J3.S3 (SHIELD), J3.S4 (SHIELD), J3.S5 (SHIELD), J3.S6 (SHIELD), SJ1.1, U1.2 (GND), U$12.P$2, U$13.P$2, U$46.P$2 (2), U$61.P$2 (2), U$79.P$3, U$80.P$2 (2), U$81.P$2 (2), U$83.P$2 (2), X2.2
IO0: IC2.25 (IO0), IO1.1, IO1.2, Q6.3 (D)
IO16: IC2.27 (IO16), U$6.P$1, U$13.P$1, U$89.P$2
IO18: IC2.30 (IO18), U$8.P$1, U$12.P$1, U$90.P$2
IO25: IC2.10 (IO25), U$4.P$1
IO26: IC2.11 (IO26), U$5.P$1
IO27: IC2.12 (IO27), U$11.P$1
IO32: IC2.8 (IO32), U$2.P$1
IO33: IC2.9 (IO33), U$3.P$1
MAIN_RX: U$84.P$3, X2.4
MAIN_TX: U$84.P$4, X2.3
unnamed: 3V.A, U$1.P$2
unnamed: Q5.1 (G), Q6.2 (S), U$79.P$4
unnamed: Q5.2 (S), Q6.1 (G), U$79.P$6
unnamed: J3.2, U$79.P$2
unnamed: IO32.A, U$2.P$2
unnamed: J3.3, U$79.P$1
unnamed: IO33.A, U$3.P$2
unnamed: IO25.A, U$4.P$2
unnamed: IO26.A, U$5.P$2
unnamed: 3V.K, IO25.K, IO26.K, IO27.K, IO32.K, IO33.K, U$10.P$3, Ⅰ_A.K, Ⅰ_B.K, Ⅱ_A.K, Ⅱ_B.K
unnamed: U$8.P$2, Ⅱ_A.A
unnamed: IO27.A, U$11.P$2
unnamed: U$9.P$2, Ⅱ_B.A
unnamed: U$9.P$1, U$90.P$1
unnamed: U$7.P$1, U$89.P$1
unnamed: U$7.P$2, Ⅰ_B.A
unnamed: U$6.P$2, Ⅰ_A.A
